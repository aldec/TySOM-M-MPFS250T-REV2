FILESEXTRAPATHS:append = ":${THISDIR}/files"

COMPATIBLE_MACHINE = "(tysom-m-mpfs250t|tysom-m-mpfs250t-amp)"
