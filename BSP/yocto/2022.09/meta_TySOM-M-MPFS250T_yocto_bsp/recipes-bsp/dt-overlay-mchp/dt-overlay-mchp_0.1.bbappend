COMPATIBLE_MACHINE = "(tysom-m-mpfs250t|tysom-m-mpfs250t-pcie|tysom-m-mpfs250t-amp)"

DT_FILES_PATH:tysom-m-mpfs250 = "${WORKDIR}/git/mpfs_icicle"
DT_FILES_PATH:tysom-m-mpfs250-pcie = "${WORKDIR}/git/mpfs_icicle"
DT_FILES_PATH:tysom-m-mpfs250t-amp = "${WORKDIR}/git/mpfs_icicle"
