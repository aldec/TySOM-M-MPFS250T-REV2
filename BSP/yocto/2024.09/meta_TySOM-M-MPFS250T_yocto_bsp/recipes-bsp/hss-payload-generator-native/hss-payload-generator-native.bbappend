FILESEXTRAPATHS:append = ":${THISDIR}/files"
