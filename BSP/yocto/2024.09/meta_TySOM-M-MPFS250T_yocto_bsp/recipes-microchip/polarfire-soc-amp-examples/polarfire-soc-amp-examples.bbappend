COMPATIBLE_MACHINE = "(tysom-m-mpfs250t-amp)"
